DESCRIPTION = "Transmission interface."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "hardware-interface cmake-modules tinyxml"
#RDEPENDS = "tinyxml"

require ros-control.inc

