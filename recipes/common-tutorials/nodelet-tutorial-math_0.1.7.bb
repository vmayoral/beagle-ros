DESCRIPTION = "nodelet_tutorial_math, recipe for cross-compiling ROS package"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;md5=e9a21ae1da6f704b4933741142a12769"

DEPENDS = "roscpp nodelet std-msgs"
RDEPENDS = "roscpp nodelet std-msgs"

require common-tutorials.inc
