DESCRIPTION = "This package contains a tool for setting and publishing joint state values for a given URDF."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=f58a44222abe011e35c8da65c1b32d5a"

DEPENDS = "rospy wxpython sensor-msgs"

require robot-model.inc
